# Keil uVision project AHT20_Measure.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AHT20_Measure +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c UART.c UART.h PLATFORM.c PLATFORM.h AHT20.c AHT20.h
